# Keil uVision project DCDEMO7.uvprojx, settings and files
target DCDEMO_F407 (ARM-ADS)
  device: STM32F407ZG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.1.0.8
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(8000000) ELITTLE
  output: DCDEMO7_F407 +hex
  c flags: Optim=4 OneElfS=1 uC99=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32F40_41xxx
  c include: ..\inc;..\..\..\Libraries\CMSIS\Device\STM32F4xx\Include;..\..\..\Libraries\CMSIS\Core\CM4;..\..\..\Libraries\STM32F4xx_StdPeriph_Driver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group User
    ../src/: main.c hw_config.c stm32f4xx_it.c ulitity.c
  group APP
    ../src/: app_spo2.c meas.c dbg_log.c
  group HMI_DRIVE
    ../src/: hmi_driver.c hmi_user_uart.c cmd_queue.c
  group StdPeriph_Driver
    ../../../Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_usart.c stm32f4xx_exti.c stm32f4xx_syscfg.c stm32f4xx_flash.c
  group CMSIS
    ../../../Libraries/CMSIS/Device/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group Startup
    ../../../Libraries/CMSIS/Device/STM32F4xx/Source/Templates/arm/: startup_stm32f40_41xxx.s
  group Doc
    ../: readme.txt
