# Keil uVision project DCDEMO7.uvprojx, settings and files
target DCDEMO (ARM-ADS)
  device: STM32F407ZG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.1.0.8
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: HMI_M3DEMO +hex
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32F10X_HD, USE_STM3210B_EVAL
  c include: ..\..\..\Libraries\CMSIS\Core\CM3;..\..\..\Libraries\STM32_USB-FS-Device_Driver\inc;..\..\..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\..\..\Utilities\STM32_EVAL;..\..\..\Utilities\STM32_EVAL\STM3210B_EVAL;..\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group User
    ../src/: hw_config.c stm32f10x_it.c main.c ulitity.c
  group StdPeriph_Driver
    ../../../Libraries/STM32F10x_StdPeriph_Driver/src/: stm32f10x_usart.c misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_flash.c stm32f10x_exti.c
  group RVMDK
    ../../../Libraries/CMSIS/Core/CM3/startup/arm/: startup_stm32f10x_hd.s startup_stm32f10x_cl.s
  group CMSIS
    ../../../Libraries/CMSIS/Core/CM3/: system_stm32f10x.c core_cm3.c
  group Doc
    ../: readme.txt
  group HMI_DRIVE
    ../src/: hmi_user_uart.c cmd_queue.c hmi_driver.c
