# Keil uVision project KEIL_DEMO_8051.uvprojx, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: lin +hex
  c flags: Optimize=9 SizeSpeed=1
  group Source Group 1
    ./src/: cmd_queue.c hmi_driver.c hmi_user_uart.c main.c STARTUP.A51 ulitity.c
